# Keil uVision project main.uvproj, settings and files
target 温度记录器 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\inc;..\User
  group STC15
    ./: STARTUP.A51
  group BSP
    ../BSP/src/: DS18B20.c bsp_key.c GPIO.c SEGLED.c DS1302.c
  group User
    ../User/: main.c user.c
