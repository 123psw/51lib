# Keil uVision project main.uvproj, settings and files
target 电子钟设计 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\USER
  group STC15
    ./: STARTUP.A51
  group FSBSP
    ../FsBSP/src/: DS1302.c SEGLED.c bsp_key.c GPIO.c
  group USER
    ../USER/: main.c user.c
